#include "mock_includes/ESP32-HUB75-MatrixPanel-I2S-DMA.h"
#include "display.h"   // single source of truth for panel dimensions
#include <SDL.h>
#include <cstring>
#include <cstdio>
#include <algorithm>

// Must match the real panel layout used by display.cpp.
static const int W          = PANEL_RES_X * PANEL_CHAIN;  // 80 * 2 = 160
static const int H          = PANEL_RES_Y;                // 40
static const int SCALE      = 8;      // window pixels per LED pixel
static const int LED_RADIUS = 3;      // dot radius (fits in SCALE/2 - 1)

// Double framebuffer: drawIdx is the back buffer, dispIdx is shown on screen.
static uint16_t buf[2][W * H];
static int drawIdx = 0;
static int dispIdx = 1;

static SDL_Window*   sdlWindow   = nullptr;
static SDL_Renderer* sdlRenderer = nullptr;
static SDL_Texture*  sdlTexture  = nullptr;
// CPU framebuffer (window resolution). We rasterize the LEDs here and upload
// the whole thing as one texture per frame — issuing thousands of individual
// SDL draw calls per frame crashes the macOS Metal backend.
static uint32_t fb[W * SCALE * H * SCALE];

// Text-rendering state
static int16_t  curX = 0, curY = 0;
static uint16_t textCol = 0xFFFF;

// Adafruit GFX 5x7 bitmap font.
// Indexed as font[ascii * 5 + col], col 0 = leftmost.
// Each byte is a column: bit 0 (LSB) = top pixel, bit 6 = bottom pixel.
static const uint8_t font[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x5B, 0x4F, 0x5B, 0x3E,
    0x3E, 0x6B, 0x4F, 0x6B, 0x3E, 0x1C, 0x3E, 0x7C, 0x3E, 0x1C,
    0x18, 0x3C, 0x7E, 0x3C, 0x18, 0x1C, 0x57, 0x7D, 0x57, 0x1C,
    0x1C, 0x5E, 0x7F, 0x5E, 0x1C, 0x00, 0x18, 0x3C, 0x18, 0x00,
    0xFF, 0xE7, 0xC3, 0xE7, 0xFF, 0x00, 0x18, 0x24, 0x18, 0x00,
    0xFF, 0xE7, 0xDB, 0xE7, 0xFF, 0x30, 0x48, 0x3A, 0x06, 0x0E,
    0x26, 0x29, 0x79, 0x29, 0x26, 0x40, 0x7F, 0x05, 0x05, 0x07,
    0x40, 0x7F, 0x05, 0x25, 0x3F, 0x5A, 0x3C, 0xE7, 0x3C, 0x5A,
    0x7F, 0x3E, 0x1C, 0x1C, 0x08, 0x08, 0x1C, 0x1C, 0x3E, 0x7F,
    0x14, 0x22, 0x7F, 0x22, 0x14, 0x5F, 0x5F, 0x00, 0x5F, 0x5F,
    0x06, 0x09, 0x7F, 0x01, 0x7F, 0x00, 0x66, 0x89, 0x95, 0x6A,
    0x60, 0x60, 0x60, 0x60, 0x60, 0x94, 0xA2, 0xFF, 0xA2, 0x94,
    0x08, 0x04, 0x7E, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x20, 0x10,
    0x08, 0x08, 0x2A, 0x1C, 0x08, 0x08, 0x1C, 0x2A, 0x08, 0x08,
    0x1E, 0x10, 0x10, 0x10, 0x10, 0x0C, 0x1E, 0x0C, 0x1E, 0x0C,
    0x30, 0x38, 0x3E, 0x38, 0x30, 0x06, 0x0E, 0x3E, 0x0E, 0x06,
    // 0x20 ' '
    0x00, 0x00, 0x00, 0x00, 0x00,
    // 0x21 '!'
    0x00, 0x00, 0x5F, 0x00, 0x00,
    // 0x22 '"'
    0x00, 0x07, 0x00, 0x07, 0x00,
    // 0x23 '#'
    0x14, 0x7F, 0x14, 0x7F, 0x14,
    // 0x24 '$'
    0x24, 0x2A, 0x7F, 0x2A, 0x12,
    // 0x25 '%'
    0x23, 0x13, 0x08, 0x64, 0x62,
    // 0x26 '&'
    0x36, 0x49, 0x56, 0x20, 0x50,
    // 0x27 '\''
    0x00, 0x08, 0x07, 0x03, 0x00,
    // 0x28 '('
    0x00, 0x1C, 0x22, 0x41, 0x00,
    // 0x29 ')'
    0x00, 0x41, 0x22, 0x1C, 0x00,
    // 0x2A '*'
    0x2A, 0x1C, 0x7F, 0x1C, 0x2A,
    // 0x2B '+'
    0x08, 0x08, 0x3E, 0x08, 0x08,
    // 0x2C ','
    0x00, 0x80, 0x70, 0x30, 0x00,
    // 0x2D '-'
    0x08, 0x08, 0x08, 0x08, 0x08,
    // 0x2E '.'
    0x00, 0x00, 0x60, 0x60, 0x00,
    // 0x2F '/'
    0x20, 0x10, 0x08, 0x04, 0x02,
    // 0x30 '0'
    0x3E, 0x51, 0x49, 0x45, 0x3E,
    // 0x31 '1'
    0x00, 0x42, 0x7F, 0x40, 0x00,
    // 0x32 '2'
    0x72, 0x49, 0x49, 0x49, 0x46,
    // 0x33 '3'
    0x21, 0x41, 0x49, 0x4D, 0x33,
    // 0x34 '4'
    0x18, 0x14, 0x12, 0x7F, 0x10,
    // 0x35 '5'
    0x27, 0x45, 0x45, 0x45, 0x39,
    // 0x36 '6'
    0x3C, 0x4A, 0x49, 0x49, 0x31,
    // 0x37 '7'
    0x41, 0x21, 0x11, 0x09, 0x07,
    // 0x38 '8'
    0x36, 0x49, 0x49, 0x49, 0x36,
    // 0x39 '9'
    0x46, 0x49, 0x49, 0x29, 0x1E,
    // 0x3A ':'
    0x00, 0x00, 0x14, 0x00, 0x00,
    // 0x3B ';'
    0x00, 0x40, 0x34, 0x00, 0x00,
    // 0x3C '<'
    0x00, 0x08, 0x14, 0x22, 0x41,
    // 0x3D '='
    0x14, 0x14, 0x14, 0x14, 0x14,
    // 0x3E '>'
    0x00, 0x41, 0x22, 0x14, 0x08,
    // 0x3F '?'
    0x02, 0x01, 0x59, 0x09, 0x06,
    // 0x40 '@'
    0x3E, 0x41, 0x5D, 0x59, 0x4E,
    // 0x41 'A'
    0x7C, 0x12, 0x11, 0x12, 0x7C,
    // 0x42 'B'
    0x7F, 0x49, 0x49, 0x49, 0x36,
    // 0x43 'C'
    0x3E, 0x41, 0x41, 0x41, 0x22,
    // 0x44 'D'
    0x7F, 0x41, 0x41, 0x41, 0x3E,
    // 0x45 'E'
    0x7F, 0x49, 0x49, 0x49, 0x41,
    // 0x46 'F'
    0x7F, 0x09, 0x09, 0x09, 0x01,
    // 0x47 'G'
    0x3E, 0x41, 0x41, 0x51, 0x73,
    // 0x48 'H'
    0x7F, 0x08, 0x08, 0x08, 0x7F,
    // 0x49 'I'
    0x00, 0x41, 0x7F, 0x41, 0x00,
    // 0x4A 'J'
    0x20, 0x40, 0x41, 0x3F, 0x01,
    // 0x4B 'K'
    0x7F, 0x08, 0x14, 0x22, 0x41,
    // 0x4C 'L'
    0x7F, 0x40, 0x40, 0x40, 0x40,
    // 0x4D 'M'
    0x7F, 0x02, 0x1C, 0x02, 0x7F,
    // 0x4E 'N'
    0x7F, 0x04, 0x08, 0x10, 0x7F,
    // 0x4F 'O'
    0x3E, 0x41, 0x41, 0x41, 0x3E,
    // 0x50 'P'
    0x7F, 0x09, 0x09, 0x09, 0x06,
    // 0x51 'Q'
    0x3E, 0x41, 0x51, 0x21, 0x5E,
    // 0x52 'R'
    0x7F, 0x09, 0x19, 0x29, 0x46,
    // 0x53 'S'
    0x26, 0x49, 0x49, 0x49, 0x32,
    // 0x54 'T'
    0x03, 0x01, 0x7F, 0x01, 0x03,
    // 0x55 'U'
    0x3F, 0x40, 0x40, 0x40, 0x3F,
    // 0x56 'V'
    0x1F, 0x20, 0x40, 0x20, 0x1F,
    // 0x57 'W'
    0x3F, 0x40, 0x38, 0x40, 0x3F,
    // 0x58 'X'
    0x63, 0x14, 0x08, 0x14, 0x63,
    // 0x59 'Y'
    0x03, 0x04, 0x78, 0x04, 0x03,
    // 0x5A 'Z'
    0x61, 0x59, 0x49, 0x4D, 0x43,
    // 0x5B '['
    0x00, 0x7F, 0x41, 0x41, 0x41,
    // 0x5C '\'
    0x02, 0x04, 0x08, 0x10, 0x20,
    // 0x5D ']'
    0x00, 0x41, 0x41, 0x41, 0x7F,
    // 0x5E '^'
    0x04, 0x02, 0x01, 0x02, 0x04,
    // 0x5F '_'
    0x40, 0x40, 0x40, 0x40, 0x40,
    // 0x60 '`'
    0x00, 0x03, 0x07, 0x08, 0x00,
    // 0x61 'a'
    0x20, 0x54, 0x54, 0x78, 0x40,
    // 0x62 'b'
    0x7F, 0x28, 0x44, 0x44, 0x38,
    // 0x63 'c'
    0x38, 0x44, 0x44, 0x44, 0x28,
    // 0x64 'd'
    0x38, 0x44, 0x44, 0x28, 0x7F,
    // 0x65 'e'
    0x38, 0x54, 0x54, 0x54, 0x18,
    // 0x66 'f'
    0x00, 0x08, 0x7E, 0x09, 0x02,
    // 0x67 'g'
    0x18, 0xA4, 0xA4, 0x9C, 0x78,
    // 0x68 'h'
    0x7F, 0x08, 0x04, 0x04, 0x78,
    // 0x69 'i'
    0x00, 0x44, 0x7D, 0x40, 0x00,
    // 0x6A 'j'
    0x20, 0x40, 0x40, 0x3D, 0x00,
    // 0x6B 'k'
    0x7F, 0x10, 0x28, 0x44, 0x00,
    // 0x6C 'l'
    0x00, 0x41, 0x7F, 0x40, 0x00,
    // 0x6D 'm'
    0x7C, 0x04, 0x78, 0x04, 0x78,
    // 0x6E 'n'
    0x7C, 0x08, 0x04, 0x04, 0x78,
    // 0x6F 'o'
    0x38, 0x44, 0x44, 0x44, 0x38,
    // 0x70 'p'
    0xFC, 0x18, 0x24, 0x24, 0x18,
    // 0x71 'q'
    0x18, 0x24, 0x24, 0x18, 0xFC,
    // 0x72 'r'
    0x7C, 0x08, 0x04, 0x04, 0x08,
    // 0x73 's'
    0x48, 0x54, 0x54, 0x54, 0x24,
    // 0x74 't'
    0x04, 0x04, 0x3F, 0x44, 0x24,
    // 0x75 'u'
    0x3C, 0x40, 0x40, 0x20, 0x7C,
    // 0x76 'v'
    0x1C, 0x20, 0x40, 0x20, 0x1C,
    // 0x77 'w'
    0x3C, 0x40, 0x30, 0x40, 0x3C,
    // 0x78 'x'
    0x44, 0x28, 0x10, 0x28, 0x44,
    // 0x79 'y'
    0x4C, 0x90, 0x90, 0x90, 0x7C,
    // 0x7A 'z'
    0x44, 0x64, 0x54, 0x4C, 0x44,
    // 0x7B '{'
    0x00, 0x08, 0x36, 0x41, 0x00,
    // 0x7C '|'
    0x00, 0x00, 0x77, 0x00, 0x00,
    // 0x7D '}'
    0x00, 0x41, 0x36, 0x08, 0x00,
    // 0x7E '~'
    0x02, 0x01, 0x02, 0x04, 0x02,
};

// ---------------------------------------------------------------------------
// Internal pixel writer — clips to framebuffer bounds.
// ---------------------------------------------------------------------------
static void putPixel(int x, int y, uint16_t color) {
    if (x < 0 || x >= W || y < 0 || y >= H) return;
    buf[drawIdx][y * W + x] = color;
}

// ---------------------------------------------------------------------------
// Render the display buffer to the SDL window.
// Each LED pixel is shown as a filled circle of radius LED_RADIUS
// inside a SCALE×SCALE cell. Off pixels get a dim dot so the grid is visible.
// ---------------------------------------------------------------------------
static inline void fbPut(int x, int y, uint32_t c) {
    if (x < 0 || x >= W * SCALE || y < 0 || y >= H * SCALE) return;
    fb[y * (W * SCALE) + x] = c;
}

static void renderFrame() {
    const uint32_t BG = 0xFF0A0A0A;  // dark background between LEDs
    for (int i = 0; i < W * SCALE * H * SCALE; i++) fb[i] = BG;

    for (int py = 0; py < H; py++) {
        for (int px = 0; px < W; px++) {
            uint16_t c = buf[dispIdx][py * W + px];
            uint8_t r, g, b;
            if (c == 0) {
                r = g = b = 20;  // dim unlit LED dot
            } else {
                r = (uint8_t)((c >> 11) << 3);
                g = (uint8_t)(((c >> 5) & 0x3F) << 2);
                b = (uint8_t)((c & 0x1F) << 3);
            }
            uint32_t col = 0xFF000000u | (r << 16) | (g << 8) | b;

            int cx = px * SCALE + SCALE / 2;
            int cy = py * SCALE + SCALE / 2;
            for (int dy = -LED_RADIUS; dy <= LED_RADIUS; dy++) {
                for (int dx = -LED_RADIUS; dx <= LED_RADIUS; dx++) {
                    if (dx * dx + dy * dy <= LED_RADIUS * LED_RADIUS)
                        fbPut(cx + dx, cy + dy, col);
                }
            }
        }
    }

    SDL_UpdateTexture(sdlTexture, nullptr, fb, W * SCALE * (int)sizeof(uint32_t));
    SDL_RenderClear(sdlRenderer);
    SDL_RenderCopy(sdlRenderer, sdlTexture, nullptr, nullptr);
    SDL_RenderPresent(sdlRenderer);
}

// ---------------------------------------------------------------------------
// MatrixPanel_I2S_DMA implementation
// ---------------------------------------------------------------------------
MatrixPanel_I2S_DMA::MatrixPanel_I2S_DMA(HUB75_I2S_CFG&) {}

MatrixPanel_I2S_DMA::~MatrixPanel_I2S_DMA() {
    if (sdlTexture)  SDL_DestroyTexture(sdlTexture);
    if (sdlRenderer) SDL_DestroyRenderer(sdlRenderer);
    if (sdlWindow)   SDL_DestroyWindow(sdlWindow);
    SDL_Quit();
}

bool MatrixPanel_I2S_DMA::begin() {
    if (SDL_Init(SDL_INIT_VIDEO) < 0) {
        fprintf(stderr, "SDL_Init: %s\n", SDL_GetError());
        return false;
    }
    sdlWindow = SDL_CreateWindow(
        "Subway Sign Simulator  [Q / Esc to quit]",
        SDL_WINDOWPOS_CENTERED, SDL_WINDOWPOS_CENTERED,
        W * SCALE, H * SCALE,
        SDL_WINDOW_SHOWN | SDL_WINDOW_ALLOW_HIGHDPI);
    if (!sdlWindow) { fprintf(stderr, "SDL_CreateWindow: %s\n", SDL_GetError()); return false; }

    sdlRenderer = SDL_CreateRenderer(sdlWindow, -1,
        SDL_RENDERER_ACCELERATED | SDL_RENDERER_PRESENTVSYNC);
    if (!sdlRenderer) { fprintf(stderr, "SDL_CreateRenderer: %s\n", SDL_GetError()); return false; }

    SDL_RenderSetLogicalSize(sdlRenderer, W * SCALE, H * SCALE);

    // Single streaming texture we upload once per frame (avoids per-pixel draw calls).
    sdlTexture = SDL_CreateTexture(sdlRenderer, SDL_PIXELFORMAT_ARGB8888,
        SDL_TEXTUREACCESS_STREAMING, W * SCALE, H * SCALE);
    if (!sdlTexture) { fprintf(stderr, "SDL_CreateTexture: %s\n", SDL_GetError()); return false; }

    memset(buf, 0, sizeof(buf));
    return true;
}

void MatrixPanel_I2S_DMA::setBrightness8(uint8_t) {}  // no-op in sim

void MatrixPanel_I2S_DMA::clearScreen() {
    memset(buf[drawIdx], 0, W * H * sizeof(uint16_t));
}

void MatrixPanel_I2S_DMA::flipDMABuffer() {
    std::swap(drawIdx, dispIdx);
    renderFrame();

    // Drain SDL events so the window stays alive and responds to quit.
    SDL_Event e;
    while (SDL_PollEvent(&e)) {
        if (e.type == SDL_QUIT)
            goto quit;
        if (e.type == SDL_KEYDOWN) {
            SDL_Keycode k = e.key.keysym.sym;
            if (k == SDLK_ESCAPE || k == SDLK_q)
                goto quit;
        }
    }
    return;

quit:
    if (sdlTexture)  { SDL_DestroyTexture(sdlTexture);   sdlTexture  = nullptr; }
    if (sdlRenderer) { SDL_DestroyRenderer(sdlRenderer); sdlRenderer = nullptr; }
    if (sdlWindow)   { SDL_DestroyWindow(sdlWindow);     sdlWindow   = nullptr; }
    SDL_Quit();
    exit(0);
}

uint16_t MatrixPanel_I2S_DMA::color565(uint8_t r, uint8_t g, uint8_t b) {
    return (uint16_t)(((r & 0xF8u) << 8) | ((g & 0xFCu) << 3) | (b >> 3));
}

void MatrixPanel_I2S_DMA::fillCircle(int16_t x0, int16_t y0, int16_t r, uint16_t color) {
    for (int16_t dy = -r; dy <= r; dy++)
        for (int16_t dx = -r; dx <= r; dx++)
            if (dx * dx + dy * dy <= r * r)
                putPixel(x0 + dx, y0 + dy, color);
}

void MatrixPanel_I2S_DMA::fillRect(int16_t x, int16_t y, int16_t w, int16_t h, uint16_t color) {
    for (int16_t j = y; j < y + h; j++)
        for (int16_t i = x; i < x + w; i++)
            putPixel(i, j, color);
}

void MatrixPanel_I2S_DMA::drawRect(int16_t x, int16_t y, int16_t w, int16_t h, uint16_t color) {
    for (int16_t i = x; i < x + w; i++) {
        putPixel(i, y,         color);
        putPixel(i, y + h - 1, color);
    }
    for (int16_t j = y + 1; j < y + h - 1; j++) {
        putPixel(x,         j, color);
        putPixel(x + w - 1, j, color);
    }
}

void MatrixPanel_I2S_DMA::drawFastVLine(int16_t x, int16_t y, int16_t h, uint16_t color) {
    for (int16_t j = y; j < y + h; j++)
        putPixel(x, j, color);
}

void MatrixPanel_I2S_DMA::drawPixel(int16_t x, int16_t y, uint16_t color) {
    putPixel(x, y, color);
}

void MatrixPanel_I2S_DMA::fillScreenRGB888(uint8_t r, uint8_t g, uint8_t b) {
    uint16_t c = color565(r, g, b);
    for (int i = 0; i < W * H; i++)
        buf[drawIdx][i] = c;
}

void MatrixPanel_I2S_DMA::setTextSize(uint8_t)  {}  // textSize=1 only; ignored
void MatrixPanel_I2S_DMA::setTextColor(uint16_t c) { textCol = c; }
void MatrixPanel_I2S_DMA::setCursor(int16_t x, int16_t y) { curX = x; curY = y; }

void MatrixPanel_I2S_DMA::print(char c) {
    uint8_t ch = (uint8_t)c;
    if (ch >= sizeof(font) / 5) ch = '?';
    for (int col = 0; col < 5; col++) {
        uint8_t line = font[(int)ch * 5 + col];
        for (int row = 0; row < 8; row++, line >>= 1)
            if (line & 1)
                putPixel(curX + col, curY + row, textCol);
    }
    curX += 6;  // 5px glyph + 1px gap
}

void MatrixPanel_I2S_DMA::print(const char* s) {
    while (s && *s) print(*s++);
}
